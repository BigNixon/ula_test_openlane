* NGSPICE file created from ula.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_2 abstract view
.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_2 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_2 abstract view
.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

.subckt ula VGND VPWR clk data_in en_in op[0] op[1] op[2] result[0] result[10] result[11]
+ result[12] result[13] result[14] result[15] result[1] result[2] result[3] result[4]
+ result[5] result[6] result[7] result[8] result[9]
XFILLER_0_27_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0985_ reg_data\[13\] _0448_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0770_ _0261_ _0262_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__nand2_1
X_0968_ _0432_ _0421_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__nand2_1
X_0899_ _0386_ _0145_ _0142_ _0379_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__o22a_1
XFILLER_0_37_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0822_ _0310_ _0311_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__nand2_1
X_0684_ reg_data\[20\] VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__inv_2
X_0753_ _0242_ _0245_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1021_ _0111_ reg_data\[31\] _0193_ _0502_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__a221o_1
XFILLER_0_16_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0805_ _0251_ _0295_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0736_ _0180_ reg_data\[20\] VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__nand2_1
X_0667_ _0160_ _0162_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__nor2_1
X_0598_ _0096_ reg_data\[16\] _0048_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_24_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0521_ _0050_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1004_ _0487_ _0207_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nand3_1
XFILLER_0_12_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0719_ _0048_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_4
Xoutput20 net20 VGND VGND VPWR VPWR result[8] sky130_fd_sc_hd__buf_2
Xoutput7 net7 VGND VGND VPWR VPWR result[10] sky130_fd_sc_hd__buf_2
XFILLER_0_5_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0984_ _0413_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0967_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__inv_2
X_0898_ reg_data\[27\] VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__inv_2
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0752_ _0189_ _0183_ _0228_ _0244_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__a31o_1
X_0821_ _0311_ _0142_ reg_data\[24\] _0111_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__a2bb2o_1
X_0683_ _0178_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1020_ _0503_ _0142_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__nor2_1
X_0735_ _0228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__inv_2
X_0804_ _0294_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__inv_2
XFILLER_0_21_96 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0666_ _0161_ _0140_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__nor2_1
X_0597_ _0085_ _0090_ _0095_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0520_ reg_data\[1\] reg_data\[0\] _0048_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1003_ _0486_ _0482_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__nand2_1
X_0718_ _0210_ _0212_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__nand2_1
X_0649_ _0112_ _0144_ _0134_ _0145_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_35_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput21 net21 VGND VGND VPWR VPWR result[9] sky130_fd_sc_hd__buf_2
Xoutput8 net8 VGND VGND VPWR VPWR result[11] sky130_fd_sc_hd__buf_2
Xoutput10 net10 VGND VGND VPWR VPWR result[13] sky130_fd_sc_hd__buf_2
XTAP_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0983_ _0467_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__inv_2
XFILLER_0_24_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0897_ _0384_ _0173_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__nand2_1
X_0966_ _0450_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_171 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0751_ _0230_ _0229_ _0243_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__o21ai_1
X_0820_ reg_data\[24\] reg_data\[8\] VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nand2_1
X_0682_ _0177_ net37 _0077_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__mux2_1
X_0949_ _0048_ _0434_ _0435_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__o21a_1
X_0734_ _0227_ _0225_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__nand2_1
X_0665_ _0136_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__inv_2
X_0803_ _0260_ _0286_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0596_ _0091_ _0092_ _0094_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__o21ai_1
X_1079_ clknet_2_3__leaf_clk _0045_ VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__dfxtp_1
Xhold10 net7 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1002_ _0482_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0648_ _0111_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__inv_2
X_0717_ _0211_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__buf_2
X_0579_ reg_data\[29\] reg_data\[28\] _0077_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput9 net9 VGND VGND VPWR VPWR result[12] sky130_fd_sc_hd__buf_2
Xoutput11 net11 VGND VGND VPWR VPWR result[14] sky130_fd_sc_hd__clkbuf_4
XTAP_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0982_ _0405_ _0439_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0896_ _0382_ _0381_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__nand2_1
X_0965_ _0449_ _0448_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_63 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0750_ _0216_ reg_data\[21\] VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__nand2_1
X_0681_ reg_data\[19\] _0130_ _0163_ _0164_ _0176_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__o221ai_1
X_0948_ net33 _0211_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__or2_1
X_0879_ _0342_ _0304_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0802_ _0292_ _0293_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__nand2_1
X_0733_ _0226_ _0216_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__nand2_1
X_0664_ _0158_ _0159_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__nand2_1
X_0595_ _0093_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__buf_6
XFILLER_0_1_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1078_ clknet_2_3__leaf_clk _0044_ VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_131 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold11 net20 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1001_ _0484_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0647_ _0134_ _0131_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__nand2_1
X_0716_ net2 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__inv_2
X_0578_ _0080_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput12 net12 VGND VGND VPWR VPWR result[15] sky130_fd_sc_hd__clkbuf_4
XTAP_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0981_ _0464_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_54 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0964_ _0448_ _0449_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__or2_1
X_0895_ _0381_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0680_ _0142_ _0165_ _0171_ _0174_ _0175_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__o221a_1
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0947_ reg_data\[28\] _0130_ _0416_ _0419_ _0433_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__o2111ai_2
X_0878_ _0366_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__inv_2
XFILLER_0_33_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0801_ _0214_ net26 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0732_ reg_data\[21\] VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__inv_2
X_0663_ _0155_ reg_data\[19\] _0094_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__nand3_1
X_0594_ net5 net4 net3 VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__nand3_4
X_1077_ clknet_2_3__leaf_clk _0043_ VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__dfxtp_1
Xhold12 net9 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1000_ _0421_ _0452_ _0450_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__o21a_1
X_0715_ _0179_ _0100_ _0192_ _0195_ _0209_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__a2111o_1
X_0646_ reg_data\[18\] reg_data\[2\] VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__nand2_1
X_0577_ reg_data\[28\] reg_data\[27\] _0077_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput13 net13 VGND VGND VPWR VPWR result[1] sky130_fd_sc_hd__buf_2
XFILLER_0_26_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_98 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0629_ _0123_ _0125_ _0126_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__and3_1
X_0980_ reg_data\[30\] reg_data\[14\] VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_66 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0894_ _0360_ reg_data\[10\] _0358_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__o21a_1
X_0963_ reg_data\[13\] _0117_ _0094_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0877_ _0364_ _0365_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__nand2_1
X_0946_ _0431_ _0207_ _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__nand3_1
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0731_ reg_data\[21\] reg_data\[5\] VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__nand2_1
X_0800_ _0291_ _0212_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0662_ _0156_ _0157_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__nand2_1
X_0593_ reg_data\[0\] VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1076_ clknet_2_3__leaf_clk _0042_ VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__dfxtp_1
X_0929_ _0414_ _0173_ _0415_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__nand3_1
XFILLER_0_30_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold13 net13 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_34 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0714_ _0206_ _0207_ _0208_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__and3_1
X_0645_ _0114_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_4
X_0576_ _0079_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1059_ clknet_2_2__leaf_clk _0025_ VGND VGND VPWR VPWR reg_data\[25\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_7_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput14 net14 VGND VGND VPWR VPWR result[2] sky130_fd_sc_hd__buf_2
XTAP_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_100 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_166 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0628_ _0122_ _0118_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__nand2_1
X_0559_ _0070_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0893_ _0378_ _0380_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__nor2_1
X_0962_ reg_data\[29\] VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__inv_2
XFILLER_0_28_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_120 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0876_ _0363_ _0360_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__nand2_1
X_0945_ _0430_ _0424_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0661_ reg_data\[19\] VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__inv_2
X_0730_ _0208_ _0199_ _0222_ _0124_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__a31o_1
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0592_ _0084_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__inv_2
X_1075_ clknet_2_3__leaf_clk _0041_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_90 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0859_ _0347_ _0348_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__nand2_1
X_0928_ _0413_ _0405_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__nand2_1
Xhold14 net14 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_16_46 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0644_ _0139_ _0137_ _0124_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0713_ _0205_ _0201_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__nand2_1
X_0575_ reg_data\[27\] reg_data\[26\] _0077_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__mux2_1
X_1058_ clknet_2_0__leaf_clk _0024_ VGND VGND VPWR VPWR reg_data\[24\] sky130_fd_sc_hd__dfxtp_2
Xoutput15 net15 VGND VGND VPWR VPWR result[3] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_112 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0558_ reg_data\[19\] reg_data\[18\] _0066_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__mux2_1
X_0627_ _0124_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__inv_2
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0961_ _0443_ _0444_ _0446_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__o21ba_1
X_0892_ _0379_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_132 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0944_ _0424_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0875_ _0360_ _0363_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0660_ _0155_ _0094_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0591_ net4 VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkinvlp_2
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_79 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1074_ clknet_2_3__leaf_clk _0040_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfxtp_1
X_0927_ _0405_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0789_ _0263_ _0259_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__nand2_1
X_0858_ _0214_ net22 VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold15 net18 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_16_58 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0643_ _0137_ _0139_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__nor2_1
X_0712_ _0125_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_4
X_0574_ _0078_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
X_1057_ clknet_2_0__leaf_clk _0023_ VGND VGND VPWR VPWR reg_data\[23\] sky130_fd_sc_hd__dfxtp_2
Xoutput16 net16 VGND VGND VPWR VPWR result[4] sky130_fd_sc_hd__clkbuf_4
XTAP_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_7_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_124 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0557_ _0069_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
X_0626_ _0091_ _0106_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__or2_2
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0609_ _0106_ _0084_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__nand2_2
X_0960_ _0111_ reg_data\[29\] _0193_ _0437_ _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__a221o_1
X_0891_ reg_data\[27\] reg_data\[11\] VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0943_ _0427_ _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__nand2_1
X_0874_ reg_data\[10\] _0117_ _0094_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0590_ _0084_ reg_data\[0\] reg_data\[16\] _0088_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__a211o_1
XFILLER_0_24_158 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_180 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1073_ clknet_2_1__leaf_clk _0039_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0857_ _0346_ _0212_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__nand2_1
X_0926_ _0410_ _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_117 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold16 net15 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dlygate4sd3_1
X_0788_ _0276_ _0277_ _0279_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_23_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0711_ _0201_ _0205_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0642_ _0138_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__inv_2
XFILLER_0_20_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0573_ reg_data\[26\] reg_data\[25\] _0077_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1056_ clknet_2_0__leaf_clk _0022_ VGND VGND VPWR VPWR reg_data\[22\] sky130_fd_sc_hd__dfxtp_2
Xoutput17 net17 VGND VGND VPWR VPWR result[5] sky130_fd_sc_hd__buf_2
X_0909_ _0395_ _0394_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__nand2_1
XTAP_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0625_ _0118_ _0122_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__or2_1
X_0556_ reg_data\[18\] reg_data\[17\] _0066_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__mux2_1
X_1039_ clknet_2_0__leaf_clk _0005_ VGND VGND VPWR VPWR reg_data\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_80 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0608_ net3 _0090_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__nor2_1
X_0539_ reg_data\[10\] reg_data\[9\] _0055_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_2_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0890_ reg_data\[27\] reg_data\[11\] VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0942_ _0370_ _0425_ _0428_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0873_ _0360_ _0145_ _0142_ _0350_ _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__o221a_1
XFILLER_0_33_148 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1072_ clknet_2_1__leaf_clk _0038_ VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dfxtp_1
X_0787_ _0111_ reg_data\[23\] _0193_ _0272_ _0278_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__a221o_1
XFILLER_0_15_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0856_ reg_data\[25\] _0130_ _0338_ _0345_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_23_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0925_ _0321_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0710_ _0203_ _0204_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__nand2_1
X_0641_ _0118_ _0120_ _0121_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__o21ai_1
X_0572_ net2 VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__buf_4
X_1055_ clknet_2_0__leaf_clk _0021_ VGND VGND VPWR VPWR reg_data\[21\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput18 net18 VGND VGND VPWR VPWR result[6] sky130_fd_sc_hd__buf_2
X_0839_ reg_data\[25\] VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__inv_2
X_0908_ _0394_ _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0624_ _0120_ _0121_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__nand2b_1
X_0555_ _0068_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
X_1038_ clknet_2_0__leaf_clk _0004_ VGND VGND VPWR VPWR reg_data\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_92 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0607_ reg_data\[16\] _0092_ _0104_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__or3_1
X_0538_ _0059_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_70 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0941_ _0364_ _0393_ _0391_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__o21ai_1
X_0872_ _0193_ _0349_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1071_ clknet_2_1__leaf_clk _0037_ VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__dfxtp_1
X_0924_ _0407_ _0313_ _0333_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__and3_1
X_0786_ _0273_ _0114_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__nor2_1
X_0855_ _0339_ _0343_ _0344_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0640_ _0135_ _0136_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__nand2_1
X_0571_ _0076_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1054_ clknet_2_0__leaf_clk _0020_ VGND VGND VPWR VPWR reg_data\[20\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_7_124 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0907_ _0374_ _0364_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0769_ _0260_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__inv_2
Xoutput19 net19 VGND VGND VPWR VPWR result[7] sky130_fd_sc_hd__buf_2
X_0838_ reg_data\[25\] reg_data\[9\] VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0623_ _0119_ reg_data\[17\] VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__nand2_1
X_0554_ reg_data\[17\] reg_data\[16\] _0066_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__mux2_1
X_1037_ clknet_2_1__leaf_clk _0003_ VGND VGND VPWR VPWR reg_data\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0606_ _0102_ _0103_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__nand2_1
X_0537_ reg_data\[9\] reg_data\[8\] _0055_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_92 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0940_ _0305_ _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_147 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0871_ reg_data\[26\] VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__inv_2
XFILLER_0_18_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1070_ clknet_2_1__leaf_clk _0036_ VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dfxtp_1
X_0854_ _0343_ _0339_ _0207_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__o21ai_1
X_0923_ _0354_ _0407_ _0409_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__a21oi_1
X_0785_ _0247_ _0269_ _0275_ _0107_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__a31o_1
XFILLER_0_30_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0570_ reg_data\[25\] reg_data\[24\] _0066_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__mux2_1
X_1053_ clknet_2_1__leaf_clk _0019_ VGND VGND VPWR VPWR reg_data\[19\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_7_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0837_ _0214_ _0326_ _0327_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__o21a_1
X_0906_ _0393_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__inv_2
X_0699_ _0182_ _0114_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__nor2_1
X_0768_ _0253_ _0255_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__nand2_1
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0622_ reg_data\[17\] _0119_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__nor2_1
X_0553_ _0067_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
X_1036_ clknet_2_1__leaf_clk _0002_ VGND VGND VPWR VPWR reg_data\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_60 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_175 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0536_ _0058_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
X_0605_ reg_data\[17\] reg_data\[1\] VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1019_ reg_data\[31\] reg_data\[15\] VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0519_ _0049_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0870_ _0357_ _0173_ _0358_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__nand3_1
X_0999_ _0430_ _0483_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__nand2_1
X_0853_ _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__inv_2
X_0922_ _0386_ reg_data\[11\] _0408_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__o21ai_1
X_0784_ _0247_ _0269_ _0275_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_23_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput1 data_in VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
XTAP_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1052_ clknet_2_1__leaf_clk _0018_ VGND VGND VPWR VPWR reg_data\[18\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_11_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0767_ _0258_ _0259_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__nand2_1
X_0836_ net32 _0212_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__or2_1
X_0905_ _0391_ _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__nand2_1
X_0698_ _0112_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0621_ net4 _0101_ _0084_ net3 VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__o211ai_2
X_0552_ reg_data\[16\] reg_data\[15\] _0066_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__mux2_1
X_1035_ clknet_2_1__leaf_clk _0001_ VGND VGND VPWR VPWR reg_data\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_33_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0819_ _0300_ _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0604_ _0098_ _0101_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0535_ reg_data\[8\] reg_data\[7\] _0055_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__mux2_1
X_1018_ reg_data\[31\] reg_data\[15\] VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0518_ reg_data\[0\] net1 _0048_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__mux2_1
X_0998_ _0423_ _0452_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__nor2_1
X_0921_ _0360_ reg_data\[10\] _0381_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__or3_1
X_0783_ _0274_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__inv_2
XFILLER_0_15_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0852_ _0340_ _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput2 en_in VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
XTAP_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1051_ clknet_2_1__leaf_clk _0017_ VGND VGND VPWR VPWR reg_data\[17\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0904_ _0390_ _0386_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__nand2_1
X_0697_ _0190_ _0173_ _0191_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__and3_1
X_0766_ _0256_ reg_data\[22\] _0093_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__nand3_1
X_0835_ reg_data\[24\] _0130_ _0308_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0620_ reg_data\[0\] _0117_ reg_data\[16\] VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__o21ai_1
X_0551_ net2 VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__buf_4
X_1034_ clknet_2_3__leaf_clk _0000_ VGND VGND VPWR VPWR reg_data\[0\] sky130_fd_sc_hd__dfxtp_2
X_0749_ _0240_ _0241_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__nand2_1
X_0818_ reg_data\[8\] VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__inv_2
X_0534_ _0057_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0603_ reg_data\[1\] VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__inv_2
X_1017_ _0498_ _0207_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_61 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0517_ net2 VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0997_ _0480_ _0481_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0920_ _0406_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__inv_2
X_0782_ _0272_ _0273_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0851_ net4 _0330_ _0084_ net3 _0329_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__o2111ai_1
XFILLER_0_23_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput3 op[0] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_4
XTAP_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1050_ clknet_2_3__leaf_clk _0016_ VGND VGND VPWR VPWR reg_data\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0834_ _0193_ _0310_ _0312_ _0324_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__a211oi_1
X_0903_ _0386_ _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__or2_1
X_0696_ _0189_ _0183_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__nand2_1
X_0765_ _0257_ _0238_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0550_ _0065_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_1033_ _0515_ _0516_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__nand2_1
X_0817_ _0297_ _0299_ _0304_ _0307_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__a31o_1
X_0679_ _0112_ _0166_ _0157_ _0145_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__o2bb2a_1
X_0748_ reg_data\[22\] reg_data\[6\] VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0533_ reg_data\[7\] reg_data\[6\] _0055_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__mux2_1
X_0602_ _0099_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__buf_4
XFILLER_0_8_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1016_ _0488_ _0480_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0996_ _0479_ _0462_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_195 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0850_ reg_data\[9\] _0117_ reg_data\[25\] _0094_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__o211ai_1
X_0781_ reg_data\[23\] reg_data\[7\] VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__nand2_1
Xinput4 op[1] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_4
XFILLER_0_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_2_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XTAP_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0979_ _0462_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0833_ _0322_ _0173_ _0323_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__and3_1
X_0902_ reg_data\[11\] _0117_ _0093_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__o21ai_1
X_0695_ _0183_ _0189_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__or2_1
X_0764_ _0256_ _0093_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1032_ _0214_ net29 VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__nand2_1
X_0747_ _0238_ _0239_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__nand2_1
X_0816_ _0306_ _0207_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__nand2_1
X_0678_ _0172_ _0173_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__nand2_1
X_0601_ _0091_ _0090_ _0086_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__and3_1
X_0532_ _0056_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1015_ _0497_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__inv_2
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_108 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0995_ _0462_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0780_ _0270_ _0271_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput5 op[2] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0978_ reg_data\[14\] VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__inv_2
XFILLER_0_20_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0763_ _0087_ net5 _0239_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__nand3_1
X_0832_ _0321_ _0313_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__nand2_1
X_0901_ _0383_ _0385_ _0388_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__o21a_1
X_0694_ _0186_ _0188_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1031_ _0514_ _0212_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_87 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0746_ reg_data\[6\] VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__inv_2
X_0815_ _0305_ _0302_ _0303_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__nand3_1
X_0677_ _0108_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0531_ reg_data\[6\] reg_data\[5\] _0055_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0600_ reg_data\[17\] VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1014_ _0494_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0729_ _0208_ _0199_ _0222_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_109 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0994_ reg_data\[14\] _0117_ _0094_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_112 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_156 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_68 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0977_ reg_data\[30\] VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__inv_2
XFILLER_0_9_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0900_ _0084_ _0090_ _0086_ _0378_ _0387_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__o41a_1
X_0693_ _0167_ _0169_ _0187_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__a21oi_1
X_0762_ _0254_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__inv_2
X_0831_ _0313_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1030_ _0501_ _0512_ _0513_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__nand3_1
X_0814_ _0297_ _0299_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0745_ reg_data\[22\] VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__inv_2
X_0676_ _0170_ _0168_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0530_ net2 VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__buf_4
XFILLER_0_28_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1013_ _0495_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0659_ _0087_ _0084_ _0154_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__nand3_1
X_0728_ _0221_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__inv_2
XFILLER_0_14_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0993_ _0475_ _0476_ _0477_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__nand3_1
XFILLER_0_1_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_168 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0976_ _0460_ _0461_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0830_ _0317_ _0320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__nand2_1
X_0692_ reg_data\[3\] _0157_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__nor2_1
X_0761_ _0199_ _0218_ _0219_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__o21ai_1
X_0959_ _0438_ _0114_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0813_ _0302_ _0303_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__nand2_1
X_0675_ _0168_ _0170_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__nor2_1
X_0744_ _0236_ _0237_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1012_ reg_data\[15\] _0117_ _0094_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0727_ _0218_ _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__nor2_1
X_0658_ reg_data\[3\] VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__inv_2
X_0589_ _0085_ net4 _0087_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__a21oi_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0992_ _0193_ _0464_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0975_ _0214_ net25 VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0760_ _0205_ _0252_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0691_ _0147_ _0185_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0958_ _0442_ _0440_ _0107_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__a21o_1
X_0889_ _0214_ _0376_ _0377_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0743_ _0214_ net27 VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__nand2_1
X_0812_ _0301_ _0300_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__nand2_1
X_0674_ _0147_ _0148_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1011_ reg_data\[31\] VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__inv_2
XFILLER_0_8_34 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0726_ _0219_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__inv_2
X_0657_ _0153_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_0588_ net4 _0086_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__nor2_4
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0709_ _0161_ _0158_ _0159_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_35_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0991_ _0462_ _0145_ _0142_ _0465_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__o22a_1
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_145 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0974_ _0459_ _0212_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0690_ _0184_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__inv_2
XFILLER_0_11_129 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0957_ _0440_ _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__nor2_1
X_0888_ net31 _0212_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0673_ reg_data\[2\] _0134_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0742_ _0235_ _0212_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__nand2_1
X_0811_ _0300_ _0301_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1010_ _0488_ _0480_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0656_ _0152_ net35 _0077_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__mux2_1
X_0725_ _0217_ reg_data\[21\] VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nand2_1
X_0587_ net3 VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__inv_4
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1 net21 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0639_ _0132_ reg_data\[18\] _0093_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__nand3_1
X_0708_ _0138_ _0202_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_102 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0990_ _0473_ _0173_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__nand3_1
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_179 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0973_ _0447_ _0457_ _0458_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__nand3_1
XFILLER_0_13_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0956_ _0413_ _0405_ _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__a21oi_1
X_0887_ reg_data\[26\] _0130_ _0359_ _0362_ _0375_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__o2111ai_4
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0810_ reg_data\[8\] _0117_ _0093_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__o21ai_1
X_0672_ _0167_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__inv_2
XFILLER_0_3_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0741_ reg_data\[21\] _0130_ _0223_ _0224_ _0234_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__o221ai_2
XFILLER_0_15_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0939_ _0425_ _0368_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__and2_1
Xclkbuf_2_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_28_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0655_ reg_data\[18\] _0130_ _0140_ _0141_ _0151_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__o221ai_1
X_0724_ reg_data\[21\] _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__nor2_1
X_0586_ _0084_ reg_data\[0\] net3 VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_18_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1069_ clknet_2_1__leaf_clk _0035_ VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold2 net16 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dlygate4sd3_1
X_0707_ _0137_ _0160_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0638_ _0133_ _0134_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__nand2_1
X_0569_ _0075_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0972_ _0100_ _0448_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0886_ _0373_ _0207_ _0374_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__nand3_1
X_0955_ reg_data\[12\] _0417_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0740_ _0142_ _0225_ _0107_ _0232_ _0233_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__o221a_1
X_0671_ _0166_ _0165_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__nand2_1
X_0938_ _0393_ _0366_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__nor2_1
X_0869_ _0356_ _0351_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0723_ net4 _0216_ _0084_ net3 VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__o211ai_2
X_0654_ _0142_ _0143_ _0146_ _0150_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__o211a_1
X_0585_ net5 VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__buf_6
X_1068_ clknet_2_1__leaf_clk _0034_ VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__dfxtp_1
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold3 net11 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0706_ _0200_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__inv_2
XFILLER_0_20_61 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0637_ reg_data\[18\] VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__inv_2
X_0568_ reg_data\[24\] reg_data\[23\] _0066_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0971_ _0455_ _0207_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__nand3_1
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_104 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0885_ _0372_ _0367_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__nand2_1
X_0954_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__inv_2
XFILLER_0_33_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0670_ _0157_ _0154_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0799_ _0280_ _0289_ _0290_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__nand3_1
X_0868_ _0351_ _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0937_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__inv_2
XFILLER_0_3_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0653_ _0147_ _0148_ _0149_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__o21ai_1
X_0722_ reg_data\[5\] VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__inv_2
XFILLER_0_18_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0584_ _0083_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
X_1067_ clknet_2_1__leaf_clk _0033_ VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold4 net10 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_37_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0705_ _0198_ _0199_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__nand2_1
X_0636_ _0132_ _0094_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0567_ _0074_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_73 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0619_ _0087_ net5 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__nand2_4
XFILLER_0_16_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0970_ _0454_ _0453_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0884_ _0367_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__or2_1
X_0953_ _0437_ _0438_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0936_ _0421_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__nand2_1
X_0798_ _0100_ _0270_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__nand2_1
X_0867_ _0352_ _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0721_ _0213_ _0215_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__nand2_1
X_0652_ _0147_ _0148_ _0107_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__a21oi_1
X_0583_ reg_data\[31\] reg_data\[30\] _0077_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__mux2_1
X_1066_ clknet_2_3__leaf_clk _0032_ VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0919_ _0380_ _0378_ _0351_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__o21ai_1
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold5 net19 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0704_ _0196_ reg_data\[20\] _0093_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__nand3_2
X_0635_ _0087_ _0084_ _0131_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__nand3_1
X_0566_ reg_data\[23\] reg_data\[22\] _0066_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1049_ clknet_2_3__leaf_clk _0015_ VGND VGND VPWR VPWR reg_data\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0618_ _0111_ reg_data\[17\] _0112_ _0102_ _0115_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__a221o_1
X_0549_ reg_data\[15\] reg_data\[14\] _0055_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0952_ reg_data\[29\] reg_data\[13\] VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__nand2_1
X_0883_ _0369_ _0371_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0866_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__inv_2
X_0935_ _0420_ _0417_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0797_ _0281_ _0287_ _0288_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0720_ _0214_ net23 VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0651_ _0144_ _0143_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0582_ _0082_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1065_ clknet_2_3__leaf_clk _0031_ VGND VGND VPWR VPWR reg_data\[31\] sky130_fd_sc_hd__dfxtp_1
X_0849_ _0306_ _0302_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__nand2_1
X_0918_ _0403_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__nand2_1
Xhold6 net17 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0703_ _0197_ _0179_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__nand2_1
X_0634_ reg_data\[2\] VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__inv_2
X_0565_ _0073_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1048_ clknet_2_3__leaf_clk _0014_ VGND VGND VPWR VPWR reg_data\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_96 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0617_ _0103_ _0114_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__nor2_1
X_0548_ _0064_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0882_ _0370_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__inv_2
X_0951_ _0436_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1081_ clknet_2_3__leaf_clk _0047_ VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0865_ _0333_ reg_data\[24\] _0309_ _0353_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__a31o_1
X_0934_ _0417_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__or2_1
X_0796_ _0287_ _0281_ _0207_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_12_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0650_ _0098_ reg_data\[1\] _0109_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__o21ai_2
X_0581_ reg_data\[30\] reg_data\[29\] _0077_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1064_ clknet_2_3__leaf_clk _0030_ VGND VGND VPWR VPWR reg_data\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0779_ reg_data\[7\] VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__inv_2
X_0848_ _0142_ _0328_ _0332_ _0337_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__o211a_1
X_0917_ reg_data\[28\] reg_data\[12\] VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__nand2_1
Xhold7 net8 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dlygate4sd3_1
X_0702_ _0196_ _0093_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0633_ _0100_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__clkinv_4
X_0564_ reg_data\[22\] reg_data\[21\] _0066_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__mux2_1
X_1047_ clknet_2_2__leaf_clk _0013_ VGND VGND VPWR VPWR reg_data\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_171 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_84 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0616_ _0113_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__inv_2
XFILLER_0_25_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0547_ reg_data\[14\] reg_data\[13\] _0055_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_55 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_88 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0881_ _0302_ _0342_ _0340_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__o21ai_1
X_0950_ reg_data\[29\] reg_data\[13\] VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_63 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1080_ clknet_2_3__leaf_clk _0046_ VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__dfxtp_1
X_0795_ _0286_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__inv_2
X_0864_ reg_data\[9\] _0329_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__nor2_1
X_0933_ reg_data\[12\] _0117_ _0094_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0580_ _0081_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1063_ clknet_2_2__leaf_clk _0029_ VGND VGND VPWR VPWR reg_data\[29\] sky130_fd_sc_hd__dfxtp_2
X_0916_ reg_data\[28\] reg_data\[12\] VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__or2_1
X_0778_ reg_data\[23\] VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__inv_2
X_0847_ _0335_ _0173_ _0336_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__nand3_1
Xhold8 net12 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dlygate4sd3_1
X_0632_ _0129_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
X_0563_ _0072_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_0701_ _0087_ net5 _0180_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__nand3_1
X_1046_ clknet_2_2__leaf_clk _0012_ VGND VGND VPWR VPWR reg_data\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_2_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_31_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0615_ _0087_ _0091_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0546_ _0063_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1029_ _0100_ _0495_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0529_ _0054_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_67 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0880_ _0305_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0932_ _0417_ _0145_ _0142_ _0404_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__o221a_1
X_0794_ _0284_ _0285_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__nand2_1
X_0863_ _0321_ _0313_ _0333_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__nand3_1
XFILLER_0_34_65 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1062_ clknet_2_2__leaf_clk _0028_ VGND VGND VPWR VPWR reg_data\[28\] sky130_fd_sc_hd__dfxtp_2
X_0915_ _0401_ _0402_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__nand2_1
X_0777_ _0239_ reg_data\[22\] VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__nand2_1
X_0846_ _0334_ _0333_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__nand2_1
Xhold9 net6 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_37_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0700_ _0111_ reg_data\[20\] _0193_ _0181_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__a221o_1
X_0631_ _0128_ net34 _0077_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__mux2_1
X_0562_ reg_data\[21\] reg_data\[20\] _0066_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_87 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1045_ clknet_2_2__leaf_clk _0011_ VGND VGND VPWR VPWR reg_data\[11\] sky130_fd_sc_hd__dfxtp_1
X_0829_ _0244_ _0315_ _0319_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0614_ _0091_ net4 net3 VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__and3_2
X_0545_ reg_data\[13\] reg_data\[12\] _0055_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__mux2_1
X_1028_ _0505_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_55 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0528_ reg_data\[5\] reg_data\[4\] _0048_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__mux2_1
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_98 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_89 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0862_ _0349_ _0350_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__nand2_1
X_0931_ _0193_ _0403_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__nand2_1
X_0793_ _0282_ reg_data\[23\] _0093_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__nand3_1
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1061_ clknet_2_2__leaf_clk _0027_ VGND VGND VPWR VPWR reg_data\[27\] sky130_fd_sc_hd__dfxtp_1
X_0845_ _0333_ _0334_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__or2_1
X_0914_ _0214_ net28 VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__nand2_1
X_0776_ _0268_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0561_ _0071_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
X_0630_ _0098_ _0100_ _0110_ _0116_ _0127_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__a2111o_1
X_1044_ clknet_2_2__leaf_clk _0010_ VGND VGND VPWR VPWR reg_data\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0828_ _0269_ _0275_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__o21ai_1
X_0759_ _0251_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__inv_2
XFILLER_0_34_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0613_ _0106_ _0091_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__and2_4
XFILLER_0_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0544_ _0062_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
X_1027_ _0508_ _0510_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_67 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0527_ _0053_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0792_ _0283_ _0270_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__nand2_1
X_0861_ reg_data\[26\] reg_data\[10\] VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__nand2_1
X_0930_ reg_data\[28\] VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__inv_2
XFILLER_0_13_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1060_ clknet_2_2__leaf_clk _0026_ VGND VGND VPWR VPWR reg_data\[26\] sky130_fd_sc_hd__dfxtp_2
X_0775_ _0267_ net36 _0077_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__mux2_1
X_0844_ _0300_ reg_data\[8\] _0323_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__o21ai_1
X_0913_ _0400_ _0212_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0560_ reg_data\[20\] reg_data\[19\] _0066_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__mux2_1
X_1043_ clknet_2_2__leaf_clk _0009_ VGND VGND VPWR VPWR reg_data\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0827_ _0271_ reg_data\[23\] VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__nand2_1
X_0758_ _0221_ _0201_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__nand2_1
X_0689_ _0148_ _0167_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0612_ _0105_ _0108_ _0109_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__and3_1
X_0543_ reg_data\[12\] reg_data\[11\] _0055_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__mux2_1
X_1026_ _0509_ _0173_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0526_ reg_data\[4\] reg_data\[3\] _0048_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1009_ _0492_ _0493_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0791_ _0282_ _0093_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__nand2_1
X_0860_ reg_data\[26\] reg_data\[10\] VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0989_ _0472_ _0466_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0912_ _0389_ _0398_ _0399_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__nand3_1
X_0774_ _0250_ _0265_ _0266_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__nand3_1
X_0843_ _0331_ _0328_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1042_ clknet_2_0__leaf_clk _0008_ VGND VGND VPWR VPWR reg_data\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0688_ _0181_ _0182_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__nand2_1
X_0757_ _0246_ _0173_ _0247_ _0249_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__a31oi_1
X_0826_ _0189_ _0316_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0611_ reg_data\[16\] _0092_ _0104_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__o21ai_1
X_0542_ _0061_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
X_1025_ _0474_ _0506_ _0507_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__nand3_1
XFILLER_0_16_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0809_ reg_data\[24\] VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__inv_2
XFILLER_0_21_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0525_ _0052_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1008_ _0214_ net24 VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0790_ _0087_ net5 _0271_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__nand3_1
XFILLER_0_3_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0988_ _0466_ _0472_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0842_ _0193_ _0331_ _0329_ _0145_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__o2bb2a_1
X_0911_ _0100_ _0386_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__nand2_1
X_0773_ _0100_ _0238_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_49 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1041_ clknet_2_0__leaf_clk _0007_ VGND VGND VPWR VPWR reg_data\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0825_ _0315_ _0183_ _0228_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__and3_1
X_0756_ _0111_ reg_data\[22\] _0112_ _0240_ _0248_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__a221o_1
X_0687_ reg_data\[20\] reg_data\[4\] VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0610_ _0107_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__inv_2
X_0541_ reg_data\[11\] reg_data\[10\] _0055_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__mux2_1
X_1024_ _0474_ _0506_ _0507_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__a21oi_1
X_0808_ _0254_ _0294_ _0298_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0739_ _0193_ _0227_ _0226_ _0145_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_1_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0524_ reg_data\[3\] reg_data\[2\] _0048_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__mux2_1
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_70 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_1007_ _0491_ _0212_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0987_ _0469_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0772_ _0253_ _0255_ _0260_ _0264_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__a31o_1
X_0841_ _0329_ _0330_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__nand2_1
X_0910_ _0396_ _0207_ _0397_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__nand3_1
XFILLER_0_37_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1040_ clknet_2_0__leaf_clk _0006_ VGND VGND VPWR VPWR reg_data\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0755_ _0241_ _0114_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__nor2_1
X_0824_ _0314_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0686_ _0179_ _0180_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0540_ _0060_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
X_1023_ _0502_ _0503_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__and2_1
X_0738_ _0229_ _0231_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__xor2_1
X_0807_ _0259_ _0286_ _0285_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_24_170 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0669_ reg_data\[19\] reg_data\[3\] VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0523_ _0051_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1006_ _0478_ _0489_ _0490_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_0986_ _0439_ _0441_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0771_ _0263_ _0125_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__nand2_1
X_0840_ reg_data\[9\] VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0969_ _0453_ _0454_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__or2_1
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0754_ _0245_ _0242_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__nand2_1
X_0823_ _0242_ _0274_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__nand2_1
X_0685_ reg_data\[4\] VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__inv_2
XFILLER_0_19_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1022_ _0463_ reg_data\[30\] VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0737_ _0191_ _0230_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__nand2_1
X_0668_ _0162_ _0160_ _0124_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__a21o_1
X_0806_ _0205_ _0296_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0599_ _0048_ net30 _0089_ _0097_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0522_ reg_data\[2\] reg_data\[1\] _0048_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1005_ _0100_ _0462_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput6 net6 VGND VGND VPWR VPWR result[0] sky130_fd_sc_hd__buf_2
XFILLER_0_37_16 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
